# IAR project AngleSens.ewp, settings and files
configuration ANSIN (ARM, debug)
  General.OGChipSelectEditMenu: MKS22FN256xxx12 NXP MKS22FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_MKS22FN256VLL12; USB_STACK_UCOSIII; FSL_RTOS_UCOSIII; ANSIN=1; ANSMA=2; APP_PLATF=ANSIN
  ICCARM.CCIncludePath2: ..\App; ..\BSP; ..\Drivers; ..\MKS22F12; ..\USB; ..\USB\OSA; ..\RTOS; ..\RTOS\uC-CPU; ..\RTOS\uCOS-III; ..\RTOS\uCOS-III\Port; ..\RTOS\uC-LIB; ..\App\USB; ..\USB\Device; ..\RTT; ..\App\USB\CDC; ..\FreeMaster; ..\VT100
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AngleSens.srec
  ILINK.IlinkOutputFile: ANSIN.out
  ILINK.IlinkIcfFile: ..\MKS22F12\MKS22FN256xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ANSMA (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MKS22FN256VLL12; USB_STACK_UCOSIII; FSL_RTOS_UCOSIII; ANSIN=1; ANSMA=2; APP_PLATF=ANSMA
  ILINK.IlinkOutputFile: ANSMA.out
configuration COIL_Research (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MKS22FN256VLL12; USB_STACK_UCOSIII; FSL_RTOS_UCOSIII; ANSIN=1; ANSMA=2; APP_PLATF=ANSIN; COIL_RESEARCH
  ICCARM.CCOptLevel: 1
  group App
    ../App/: ANSIN_task.c ANSIN_task.h ANSMA_task.c ANSMA_task.h App.h cpu_cfg.h CRC_utils.c CRC_utils.h FreeMaster_vars.c Host_channel.c Host_channel.h LED_control.c LED_control.h Main.c Mesurements.c Mesurements.h os_cfg.h os_cfg_app.h OS_misc.c OS_misc.h
  group App/USB
    ../App/USB/: usb_device_ch9.c usb_device_ch9.h usb_device_class.c usb_device_class.h usb_device_config.h
  group App/USB/CDC
    ../App/USB/CDC/: usb_composite_dev.c usb_composite_dev.h usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_descriptor.c usb_device_descriptor.h usb_virtual_com1.c usb_virtual_com1.h usb_virtual_com2.c usb_virtual_com2.h
  group BSP
    ../BSP/: ANSIN01_ADC.c ANSIN01_ADC.h ANSIN01_DMA.c ANSIN01_DMA.h ANSIN01_Flash.c ANSIN01_Flash.h ANSIN01_INIT_SYS.c ANSIN01_INIT_SYS.h ANSIN01_LDC1101.c ANSIN01_LDC1101.h ANSIN01_Pins.c ANSIN01_pins.h ANSIN01_PIT.c ANSIN01_PIT.h ANSIN01_SPI.c ANSIN01_SPI.h ANSIN01_SPI_HOST.c ANSIN01_SPI_HOST.h BSP.h
  group Drivers
    ../Drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_device_registers.h fsl_gpio.c fsl_gpio.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h
  group FreeMaster
    ../FreeMaster/: freemaster.h freemaster_appcmd.c freemaster_cfg.h freemaster_defcfg.h freemaster_os.c freemaster_os.h freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_sfio.c freemaster_tsa.c freemaster_tsa.h Task_FreeMaster.c Task_FreeMaster.h
  group MKS22F12
    ../MKS22F12/: clock_config.c clock_config.h MKS22F12.h MKS22F12_features.h startup_MKS22F12.s system_MKS22F12.c system_MKS22F12.h
  group RTOS/uC-CPU
    ../RTOS/uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group RTOS/uC-LIB
    ../RTOS/uC-LIB/: lib_ascii.c lib_ascii.h lib_cfg.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group RTOS/uCOS-III
    ../RTOS/uCOS-III/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_mon.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group RTOS/uCOS-III/Port
    ../RTOS/uCOS-III/Port/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group RTT
    ../RTT/: Debug_io.c Debug_io.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group USB/Device
    ../USB/Device/: usb_device.h usb_device_dci.c usb_device_dci.h usb_device_khci.c usb_device_khci.h
  group USB/OSA
    ../USB/OSA/: usb_osa.h usb_osa_ucosiii.c usb_osa_ucosiii.h
  group VT100
    ../VT100/: Monitor_LDC1101.c Monitor_LDC1101.h Monitor_usb_drv.c Monitor_usb_drv.h MonitorVT100.c MonitorVT100.h
